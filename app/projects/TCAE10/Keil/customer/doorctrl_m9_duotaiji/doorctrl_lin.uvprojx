# Keil uVision project doorctrl_lin.uvprojx, settings and files
target TCSDK (6130001::V6.13.1::.\ARMCLANG)
  device: TCAE10 TinyChip
  pack: TinyChip.TCxx_DFP.1.1.1
  cpu: IRAM(0x10000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: doorctrl_lin +hex
  AfterMake: fromelf -c ./Objects/@H.axf -o ./Objects/@H.txt
  AfterMake: fromelf --m32combined --output=$L@L.s19 !L
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: __TCAE10__
  c include: ..\..\..\..\..\driver\inc\reg;..\..\..\..\..\driver\inc;..\..\..\..\..\midware\tclog;..\..\..\..\..\device\common\inc;..\..\..\..\..\prebuild\si_lib;..\..\..\..\..\midware\touch;.\Source;..\..\..\..\..\os\litetask;..\..\..\..\..\midware\common;.\lin_cfg;..\..\..\..\..\midware\lin_manager\inc;..\..\..\..\..\platform\pal\pal_lin\inc;..\..\..\..\..\platform\pal\utilities\inc;..\..\..\..\..\midware\store_manager\inc;..\..\..\..\..\platform\pal\pal_store\inc;..\..\..\..\..\platform\pal\pal_pmu\inc;..\..\..\..\..\prebuild\colormix\inc;..\..\..\..\..\platform\pal\pal_meas\inc;..\..\..\..\..\platform\pal\pal_led\inc;..\..\..\..\..\prebuild\lin_lib\inc;..\..\..\..\..\midware\log_manager\inc;..\..\..\..\..\midware\task_manager
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: .\Scripts\flash.sct
  link misc: --entry=Reset_Handler
  group common
    ../../../../../device/common/src/: startup_tcae10.s system_tcae10.c
  group driver
    ../../../../../driver/src/: tcae10_ll_uart.c tcae10_ll_gpio.c tcae10_ll_sys.c tcae10_ll_delay.c tcae10_ll_wdg.c tcae10_ll_lpm.c tcae10_ll_adc.c tcae10_ll_captouch.c tcae10_ll_timer.c tcae10_ll_pwm.c tcae10_ll_cortex.c tcae10_ll_sci.c tcae10_ll_flash.c
  group app
    ./Source/: tc_conf.h app.c app.h touch_config.h touch_config.c lin_frame.c custom_diagnosticIII.c custom_diagnosticIII.h
    ./lin_cfg/: lin_cfg.c lin_cfg.h lin_hw_cfg.h
  group midware
    ../../../../../midware/common/: tc_usermsg.h tc_halt.c tc_halt.h misc.c misc.h
    ../../../../../midware/store_manager/inc/: store_map.h
    ../../../../../midware/task_manager/: lin_task.h lin_task.c
  group pal
    ../../../../../platform/pal/pal_store/inc/: pal_store.h
    ../../../../../platform/pal/pal_store/: pal_store.c
    ../../../../../platform/pal/pal_pmu/inc/: pal_pmu.h
    ../../../../../platform/pal/pal_pmu/: pal_pmu.c
    ../../../../../platform/pal/utilities/inc/: utilities.h
    ../../../../../platform/pal/utilities/: utilities.c
  group touch
    ../../../../../midware/touch/: touch_halnode.c touch_halnode.h si_touch_port.c si_touch_port.h touch_include.h touch_tool.c touch_tool.h touch_haldispatch.c touch_haldispatch.h
  group tclog
    ../../../../../midware/tclog/: tc_log.c tc_log.h tc_log_conf.h
  group litetask
    ../../../../../os/litetask/: tc.c tc.h tc_port.c tc_port.h
  group lib
    ../../../../../prebuild/: silib.lib
    ../../../../../prebuild/lin_lib/: linlib_seres.lib
  group lin_manager
    ../../../../../midware/lin_manager/: diagnosticIII.c lin_process.c lin_wakeup.c
  group lin_diag
    ../../../../../midware/lin_manager/diag_sid/: sid_0x2e.c sid_0x2f.c sid_0x3e.c sid_0x11.c sid_0x32.c sid_0xb0.c sid_0xb1.c sid_0xb2.c sid_0xb3.c sid_0xb5.c sid_0xb6.c sid_0xb7.c sid_0xbc.c sid_0xbd.c
  group lin_pal
    ../../../../../platform/pal/pal_lin/inc/: pal_lin_comm.h
    ../../../../../platform/pal/pal_lin/: pal_lin_comm.c
  group store_manager
    ../../../../../midware/store_manager/: store_manager.c
target TCSDK_BOOT (6160000::V6.16::ARMCLANG)
  device: TCAE10 TinyChip
  pack: TinyChip.TCxx_DFP.1.1.1
  cpu: as above
  output: doorctrl_lin +hex
  AfterMake: fromelf -c ./Objects/@H.axf -o ./Objects/@H.txt
  AfterMake: "C:\Program Files\srecord\bin\srec_cat.exe" Objects\doorctrl_lin.hex -intel -fill 0xFF 0x4000 0xE400 -o Objects\output_full.hex -intel
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __TCAE10__, APP_MATCH_BOOT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: .\Scripts\flash_boot.sct
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.5.0
